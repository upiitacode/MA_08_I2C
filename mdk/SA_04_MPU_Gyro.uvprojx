# Keil uVision project SA_04_MPU_Gyro.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.0.0
  cpu: IROM(0x00000000,0x040000) IRAM(0x20000000,0x008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: SA_04_MPU_Gyro
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c include: ..\include;..\retarget\include
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group source
    ../source/: delay.c I2CBus_TM4C.cc main.cc MPU6050.cc RGBLed.cc SquareIntegral.cc Threshold.cc
    ../retarget/source/: serial_stream.cc serial_stream_tm4c.cc
software components: CMSIS:CORE 4.1.0, CMSIS:RTOS:Keil RTX 4.78.0, Device:Startup 1.0.0
